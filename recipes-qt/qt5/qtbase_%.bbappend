PACKAGECONFIG:append = " accessibility fontconfig linuxfb no-opengl tslib"
PACKAGECONFIG:remove = "examples tests"
