INITSCRIPT_PARAMS = "start 4 S . stop 20 0 1 6 ."
